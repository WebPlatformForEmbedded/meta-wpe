inherit setuptools3
require python-jsonref.inc

