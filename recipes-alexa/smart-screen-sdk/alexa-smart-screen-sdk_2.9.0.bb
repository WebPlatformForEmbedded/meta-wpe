require alexa-smart-screen-sdk.inc

PACKAGECONFIG_append = " gstreamer jsguiclient portaudio"

