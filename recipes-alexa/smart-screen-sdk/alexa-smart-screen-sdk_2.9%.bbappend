SRC_URI_append = " \
    file://0001-Allow-in-source-builds.patch \
    file://0002-Enable-Sample-Apps-API-to-use.patch \
    file://0003-Allow_disabling_GUIClient_and_set_install_path.patch \
    file://0004-WorkArround-to-avoid-cancel-and-statechange-on-the-same-objects.patch \
    file://0005-Install-includes-in-AVSSDK-directory.patch \
    file://0006-GUIClient-set-npm-install-path-to-cmake-current-source-dir.patch \
"

