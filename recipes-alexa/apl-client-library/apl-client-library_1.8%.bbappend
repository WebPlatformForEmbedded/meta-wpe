SRC_URI_append = " \
    file://0001-enable-tests-only-in-standalone.patch \
    file://0002-install-apl-client-js.patch \
    file://0003-remove-apl-core-install-from-client-library.patch \
"
