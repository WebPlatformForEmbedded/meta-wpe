#
#   Copyright (c) 2019 Amazon.com, Inc.
#
#   SPDX-License-Identifier: Apache-2.0
#

require avs-device-sdk.inc

PACKAGECONFIG_append = " gstreamer portaudio kwd"

