SRC_URI_append = " \
    file://0001-Allow-in-source-builds.patch \
    file://0002-Install-includes-in-AVS-directory.patch \
    file://0003-Enable-Sample-Apps-API-to-use.patch \
    file://0004-set-visibility-default-to-avoid-issue-with-hidden-case.patch \
"

