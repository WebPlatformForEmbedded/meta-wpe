SRC_URI_append = " \
    file://0001-build_yoga_static_lib_with_pic.patch \
"

