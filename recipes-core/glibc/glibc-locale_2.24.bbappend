FILES:kernel-base += "/usr/share/i18n/charmaps/*"
FILES:kernel-base += "/usr/share/i18n/locales/*"
FILES:kernel-base += "/usr/lib/gconv/*"
FILES:kernel-base += "/usr/share/i18n*"

FILES:${PN} += "/usr/share/i18n/charmaps/*"
FILES:${PN} += "/usr/share/i18n/locales/*"
FILES:${PN} += "/usr/lib/gconv/*"
FILES:${PN} += "/usr/share/i18n*"
