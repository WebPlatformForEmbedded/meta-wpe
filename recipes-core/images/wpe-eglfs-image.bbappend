require recipes-core/images/wpe-permissions.inc

