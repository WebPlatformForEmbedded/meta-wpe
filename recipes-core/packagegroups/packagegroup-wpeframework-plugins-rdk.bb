DESCRIPTION = "Web Platform for Embedded Framework Packagegroup for shared RDK plugins"
LICENSE = "MIT"

inherit packagegroup

PACKAGES = "packagegroup-wpeframework-plugins-rdk"

RDEPENDS_packagegroup-wpeframework-plugins-rdk = "wpeframework-plugins-rdk"

