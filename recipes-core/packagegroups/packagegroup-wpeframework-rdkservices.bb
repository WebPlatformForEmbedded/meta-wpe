DESCRIPTION = "Web Platform for Embedded Framework Packagegroup RDK specific plugins"
LICENSE = "MIT"

inherit packagegroup

PACKAGES = "packagegroup-wpeframework-rdkservices"

RDEPENDS_packagegroup-wpeframework-rdkservices = "wpeframework-rdkservices"

