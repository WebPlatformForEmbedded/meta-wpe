PACKAGECONFIG[graphite] = "--with-graphite2=yes,--with-graphite2=no,graphite2"
PACKAGECONFIG_append_class-target = " icu graphite"
