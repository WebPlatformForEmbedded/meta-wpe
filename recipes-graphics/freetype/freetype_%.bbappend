PACKAGECONFIG_append = " zlib pixmap"
