
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

SRC_URI += " \
    file://0016-WAYLAND-dependency-for-khronos.patch \
"

