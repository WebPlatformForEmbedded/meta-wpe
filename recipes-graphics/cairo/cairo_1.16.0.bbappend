FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = " file://0001-add-noaa-compositor-for-v1.16.patch"

