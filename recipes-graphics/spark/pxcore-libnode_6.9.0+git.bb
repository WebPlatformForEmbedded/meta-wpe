include pxcore-libnode.inc

NODE_LIB_VERSION = "48"
PV = "6.9.0"
