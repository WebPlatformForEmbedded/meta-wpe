FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://wayland-egl-bnxs-nxjoin.patch"
