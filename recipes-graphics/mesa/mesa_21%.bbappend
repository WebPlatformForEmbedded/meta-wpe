SRC_URI += "\
    file://0003-vc4-add-meson-option-to-disable-optional-neon-suppor.patch \
    file://0004-src-util-rand_xor-Include-stddef.h-to-fix-build-erro.patch \
"