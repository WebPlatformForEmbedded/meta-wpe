require libwpe.inc

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=371a616eb4903c6cb79e9893a5f615cc"

SRC_URI = "git://github.com/WebPlatformForEmbedded/libwpe.git;protocol=git;branch=libwpe-1.6"
SRCREV = "5a4dec7efbf49511a0ec6f589337b2840144e799"
