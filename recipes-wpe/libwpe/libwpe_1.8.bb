
require libwpe.inc

LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://COPYING;md5=371a616eb4903c6cb79e9893a5f615cc"

SRC_URI = "git://github.com/WebPlatformForEmbedded/libwpe.git;protocol=git;branch=libwpe-1.8"
SRCREV = "4c763f419f8dfea96b097ada744e0cc2bad9189f"