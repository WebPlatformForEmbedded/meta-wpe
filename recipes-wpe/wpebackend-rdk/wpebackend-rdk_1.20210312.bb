require wpebackend-rdk.inc

PV = "1.20210312"
SRCREV = "1cbbe13d347381cb5ff5aa717905fb55d76bd5e8"
