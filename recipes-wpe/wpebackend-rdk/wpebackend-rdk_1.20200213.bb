require wpebackend-rdk.inc

PV = "1.20200213"
SRCREV = "3ec8dfd1a1f1cede256fd5de0a63a8c6b6a31ffa"
