
REFSW_GIT_URL = "git@github.com/Metrological/bcm-refsw.git"
REFSW_SRCREV = "6b075cb3b98abeac116bd63795c8b7860d64f6bd"

RPROVIDES_${PN} += "libgl"

S = "${WORKDIR}/git"
