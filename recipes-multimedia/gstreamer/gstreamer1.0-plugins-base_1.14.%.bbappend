FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
    file://0001-Revert-uridecodebin-Use-the-correct-caps-name-for-MS.patch \
"
