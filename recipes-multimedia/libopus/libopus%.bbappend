DEPENDS_remove = "ne10"

